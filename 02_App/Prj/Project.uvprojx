# Keil uVision project Project.uvprojx, settings and files
target D3_A32FB_GD32E503RE (6160000::V6.16::ARMCLANG)
  device: GD32E503RE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.4.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: D3_A32FB_GD32E503 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: GD32E50X,GD32E50X_HD
  c misc: -Wno-invalid-source-encoding
  c include: ..\Src\Core\Inc;..\Src\Drivers\GD32E50x_Firmware_Library\GD32E50x_standard_peripheral\Include;..\Src\Drivers\GD32E50x_Firmware_Library\CMSIS\GD\GD32E50x\Include;..\Src\Core;..\Src\BSW\SystemService\OS\FreeRTOS\Source\include;..\Src\BSW\SystemService\OS\FreeRTOS\Source\CMSIS_RTOS_V2;..\Src\BSW\SystemService\OS\FreeRTOS\Source\portable\GCC\ARM_CM33_NTZ\non_secure;..\Src\Drivers\GD32E50x_Firmware_Library\CMSIS;..\Src;..\Src\BSW\MCAL;..\Src\Common;..\Src\BSW\ComplexDeviceDriver;..\Src\ASW\ASW_CHG;..\Src\BSW\SystemService\SystemM;..\Src\BSW\DebugService\LogM;..\Src\ThirdPartyLib\FlashDB\port\fal\inc;..\Src\ThirdPartyLib\FlashDB\inc;..\Src\BSW\MemoryService\FlashDB_Adapter;..\Src\BSW\MemoryService\MemIf;..\Src\BSW\MemoryService\NVM;..\Src\BSW\MemoryService\EA
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7c000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group ASW/CHG
    ../Src/ASW/ASW_CHG/: Asw_ErrorHandleConfig.c Asw_ErrorHandle.c Asw_TempHandle.c Asw_VoltCurHandle.c Asw_VoltCurHandleConfig.c Asw_EVSE.c Asw_Charge.c
  group BSW/ComplexDeviceDriver
    ../Src/BSW/ComplexDeviceDriver/: Cdd_Relay.c Cdd_CP.c Cdd_CPConfig.c Cdd_Rcd.c Cdd_Sensor.c Cdd_SensorConfig.c Cdd_RelayConfig.c Cdd_PE.c
  group BSW/MemoryService
    ../Src/BSW/MemoryService/FlashDB_Adapter/: fal_flash_w25qxx_port.c FlashDB_KVDB_Adapt.c FlashDB_TSDB_Adapt.c FlashDB_KVDB_AdaptConfig.c FlashDB_TSDB_AdaptConfig.c
    ../Src/BSW/MemoryService/EA/: W25QXX.c
    ../Src/BSW/MemoryService/NVM/: MS_Nvm.c MS_NvmConfig.c
    ../Src/BSW/MemoryService/MemIf/: MS_MemIf.c MS_MemIfConfig.c
  group BSW/MCAL
    ../Src/BSW/MCAL/: Mcal_Mcu.c Mcal_If.c Mcal_Port.c Mcal_PortConfig.c Mcal_PWM.c Mcal_PWMConfig.c Mcal_ADC.c Mcal_ADCConfig.c Mcal_Uart.c Mcal_UartConfig.c Mcal_IWDG.c Mcal_SPI.c Mcal_SPIConfig.c
  group BSW/DebugService
    ../Src/BSW/DebugService/LogM/: DS_LogM.c DS_LogMConfig.c
  group BSW/SystemService
    ../Src/BSW/SystemService/SystemM/: SS_SystemM.c
  group ThirdParty/FlashDB
    ../Src/ThirdPartyLib/FlashDB/src/: fdb.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
  group ThirdParty/Fal
    ../Src/ThirdPartyLib/FlashDB/port/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group Drivers/GD32E50x_Driver
    ../Src/Drivers/GD32E50x_Firmware_Library/GD32E50x_standard_peripheral/Source/: gd32e50x_adc.c gd32e50x_bkp.c gd32e50x_can.c gd32e50x_cmp.c gd32e50x_crc.c gd32e50x_ctc.c gd32e50x_dac.c gd32e50x_dbg.c gd32e50x_dma.c gd32e50x_enet.c gd32e50x_exmc.c gd32e50x_exti.c gd32e50x_fmc.c gd32e50x_fwdgt.c gd32e50x_gpio.c gd32e50x_i2c.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_rtc.c gd32e50x_sdio.c gd32e50x_shrtimer.c gd32e50x_spi.c gd32e50x_sqpi.c gd32e50x_timer.c gd32e50x_tmu.c gd32e50x_usart.c gd32e50x_wwdgt.c
  group Common
    ../Src/Common/: Common.c Filter.c CycleBuf.c
  group Core
    ../Src/Drivers/GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/: system_gd32e50x.c
    ../Src/Drivers/GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/ARM/: startup_gd32e50x_hd.s
    ../Src/: SysCfg.h
    ../Src/Core/: main.c portTask.c utils.c
  group OS
    ../Src/BSW/SystemService/OS/FreeRTOS/Source/portable/GCC/ARM_CM33_NTZ/non_secure/: portasm.c port.c
    ../Src/BSW/SystemService/OS/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Src/BSW/SystemService/OS/FreeRTOS/Source/portable/Common/: mpu_wrappers.c
    ../Src/BSW/SystemService/OS/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Src/BSW/SystemService/OS/FreeRTOS/Source/: timers.c tasks.c stream_buffer.c queue.c list.c event_groups.c croutine.c
    ../Src/Core/: freertos.c
software components: CMSIS:CORE 5.4.0
