# Keil uVision project Project.uvprojx, settings and files
target boot_gd32e503 (6160000::V6.16::ARMCLANG)
  device: GD32E503RE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.4.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: boot-gd32e503 +hex
  AfterMake: fromelf.exe --bin -o ./gd32e503/bin/boot-pile-tcu-ctrl.bin ./gd32e503/build/boot-gd32e503.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E50X,GD32E50X_HD
  c include: ..\Src\Core\Inc;..\Src\App;..\Src\Bsp;..\Src\Drivers\GD32E50x_Firmware_Library\CMSIS;..\Src\Drivers\GD32E50x_Firmware_Library\CMSIS\GD\GD32E50x\Include;..\Src\Drivers\GD32E50x_Firmware_Library\GD32E50x_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ../Src/Drivers/GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/ARM/: startup_gd32e50x_hd.s
    ../Src/Drivers/GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
  group Application/User/Core
    ../Src/Core/Src/: gd32e23x_it.c gd32e50x_it.c
  group App
    ../Src/App/: main.c AppOta.c
  group Bsp
    ../Src/Bsp/: bsp_delay.c bsp_spi.c bsp_flash.c bsp_w25qxx.c bsp_gd25qxx.c bsp_logUart.c
  group Drivers/CMSIS
    ../Src/Drivers/GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/: system_gd32e50x.c
    ../Src/Drivers/GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group Drivers/GD32E23x_Driver
    ../Src/Drivers/GD32E23x_Firmware_Library/GD32E23x_standard_peripheral/Source/: gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_rcu.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group Drivers/GD32E50x_Driver
    ../Src/Drivers/GD32E50x_Firmware_Library/GD32E50x_standard_peripheral/Source/: gd32e50x_fmc.c gd32e50x_fwdgt.c gd32e50x_gpio.c gd32e50x_i2c.c gd32e50x_misc.c gd32e50x_rcu.c gd32e50x_spi.c gd32e50x_timer.c gd32e50x_usart.c gd32e50x_wwdgt.c
target boot_gd32e230 (6160000::V6.16::ARMCLANG)
  device: GD32E503RE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.4.0
  cpu: as above
  output: boot-gd32e230 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe --bin --output ./gd32e230/bin/pile-ccu-ctrl.bin ./gd32e230/build/boot-gd32e230.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: GD32E230
  c include: ..\Src\Core\Inc;..\Src\App;..\Src\Bsp;..\Src\Drivers\GD32E23x_Firmware_Library\CMSIS;..\Src\Drivers\GD32E23x_Firmware_Library\CMSIS\GD\GD32E23x\Include;..\Src\Drivers\GD32E23x_Firmware_Library\GD32E23x_standard_peripheral\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.4.0
