# Keil uVision project Project.uvprojx, settings and files
target AC_SCU_GD32E503RE (6160000::V6.16::ARMCLANG)
  device: GD32E503RE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.4.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: ccu_gd32e503 +hex
  AfterMake: fromelf.exe --bin -o ./gd32e503/bin/pile-tcu-ctrl.bin ./gd32e503/build/ccu_gd32e503.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E50X,GD32E50X_HD
  c misc: -Wno-invalid-source-encoding
  c include: ..\Src\Core\Inc;..\Src\Asw\AppLayer;..\Src\Asw\Lib;..\Src\Asw\Gprs;..\Src\Asw\ProtoLayer;..\Src\Bsw\NalLayer;..\Src\Bsw\FicaLayer;..\Src\Bsw\FocaLayer;..\Src\Bsw\RicaLayer;..\Src\Bsw\TtlLayer\FreeRTOS\Source\include;..\Src\Bsw\TtlLayer\FreeRTOS\Source\portable\GCC\ARM_CM33_NTZ\non_secure;..\Src\Drivers\GD32E50x_Firmware_Library\CMSIS;..\Src\Bsw\TtlLayer\FreeRTOS\Source\CMSIS_RTOS_V2;..\Src\Drivers\GD32E50x_Firmware_Library\CMSIS\GD\GD32E50x\Include;..\Src\Drivers\GD32E50x_Firmware_Library\GD32E50x_standard_peripheral\Include;..\Src\Asw\Module;..\Src\Asw\mbedtls\include;..\Src\Asw\mbedtls\configs;..\Src\Asw\mbedtls\mbedtls\library;..\Src\Asw\mbedtls\mbedtls\include;..\Src\Asw\mbedtls\ports\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x7c000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ../Src/Drivers/GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/ARM/: startup_gd32e50x_hd.s
    ../Src/Drivers/GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
  group Application/User/Core
    ../Src/Core/Src/: freertos.c gd32e23x_it.c gd32e50x_it.c main.c main.cpp systemTaskMain.c
    ../Src/Core/: utils.c
    ../Src/Drivers/: GeneralDriverLib_GD32E503.lib
  group Asw/AppLayer
    ../Src/Asw/AppLayer/: ota_Interface.c AppStorage.c AppCommon.cpp AppRunLog.cpp AppRunTime.cpp AppInputCfg.c AppEvenCycle.c cost.c AppDealFlash.c AppCfg.c AppMidDataTrans.c
  group Asw/ProtoLayer
    ../Src/Asw/ProtoLayer/: protocol_ctrl.c protocol_data.c mbsDataUpdate.c mbsMaster.c tcpData.c modbus.c tcp_gn.c iot_GN_Protocol_Code.c iot_YKC_Protocol_Code.c iot_Monitor_Code.c iot_Monitor_Ctrl.c iot_ANPEI_Protocol_Code.c iot_YKC_Protocol_CodeV2_1.c iot_AHTT_Protocol_Code.c iot_HNCT_Protocol_Code.c iot_WJY_Protocol_Code.c
  group Asw/Gprs
    ../Src/Asw/Gprs/: Communication.c Gprslib.c SIM900A.c Uart.c CommInterface.c
  group Asw/Lib
    ../Src/Asw/Lib/: cJSON.c common.c malloc.c Libqueue.c aes.c md5.c sha256.c rsaOwn.c
  group Bsw/NalLayer
    ../Src/Bsw/NalLayer/: FunctionalInitSummary.c GpioRouteManage.c UartRouteManage.c InfoStoreRouteManage.c
  group Asw/Module
    ../Src/Asw/Module/: card_user.c rf_card.c rgb_led.c rgb_led_scan.c rgb2hvs.c screenUart.c key.c DisQRCode.c
  group Asw/Mbedtls
    ../Src/Asw/mbedtls/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../Src/Asw/mbedtls/ports/src/: aes_alt.c arc4_alt.c des_alt.c md5_alt.c rsa_alt.c sha1_alt.c sha256_alt.c sha512_alt.c timing_alt.c
target AC_CCU_GD32E230C8 (6140000::V6.14::ARMCLANG)
  device: GD32E503RE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.4.0
  cpu: as above
  output: pile-ccu-ctrl +hex
  AfterMake: D:\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe --bin --output ./gd32e230/bin/pile-ccu-ctrl.bin ./gd32e230/build/pile-ccu-ctrl.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: GD32E230
  c include: ..\Src\User;..\Src\Core\Inc;..\Src\Bsw\RicaLayer;..\Src\Bsw\FicaLayer;..\Src\Bsw\FocaLayer;..\Src\Bsw\TtlLayer\FreeRTOS\Source\include;..\Src\Bsw\TtlLayer\FreeRTOS\Source\portable\GCC\ARM_CM23\non_secure;..\Src\Drivers\GD32E23x_Firmware_Library\CMSIS;..\Src\Drivers\GD32E23x_Firmware_Library\CMSIS\GD\GD32E23x\Include;..\Src\Drivers\GD32E23x_Firmware_Library\GD32E23x_standard_peripheral\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.4.0
