#include "AppCommon.h"
#include "string.h"

const uint8_t aucCRCHi[] = {
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
	0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
	0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
	0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
	0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
	0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
	0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
	0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
	0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
	0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40
};

const uint8_t aucCRCLo[] = {
	0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06, 0x07, 0xC7, 0x05, 0xC5, 0xC4, 0x04,
	0xCC, 0x0C, 0x0D, 0xCD, 0x0F, 0xCF, 0xCE, 0x0E, 0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09, 0x08, 0xC8,
	0xD8, 0x18, 0x19, 0xD9, 0x1B, 0xDB, 0xDA, 0x1A, 0x1E, 0xDE, 0xDF, 0x1F, 0xDD, 0x1D, 0x1C, 0xDC,
	0x14, 0xD4, 0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3, 0x11, 0xD1, 0xD0, 0x10,
	0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3, 0xF2, 0x32, 0x36, 0xF6, 0xF7, 0x37, 0xF5, 0x35, 0x34, 0xF4,
	0x3C, 0xFC, 0xFD, 0x3D, 0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A, 0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38,
	0x28, 0xE8, 0xE9, 0x29, 0xEB, 0x2B, 0x2A, 0xEA, 0xEE, 0x2E, 0x2F, 0xEF, 0x2D, 0xED, 0xEC, 0x2C,
	0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26, 0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0,
	0xA0, 0x60, 0x61, 0xA1, 0x63, 0xA3, 0xA2, 0x62, 0x66, 0xA6, 0xA7, 0x67, 0xA5, 0x65, 0x64, 0xA4,
	0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F, 0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB, 0x69, 0xA9, 0xA8, 0x68,
	0x78, 0xB8, 0xB9, 0x79, 0xBB, 0x7B, 0x7A, 0xBA, 0xBE, 0x7E, 0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C,
	0xB4, 0x74, 0x75, 0xB5, 0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71, 0x70, 0xB0,
	0x50, 0x90, 0x91, 0x51, 0x93, 0x53, 0x52, 0x92, 0x96, 0x56, 0x57, 0x97, 0x55, 0x95, 0x94, 0x54,
	0x9C, 0x5C, 0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E, 0x5A, 0x9A, 0x9B, 0x5B, 0x99, 0x59, 0x58, 0x98,
	0x88, 0x48, 0x49, 0x89, 0x4B, 0x8B, 0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C,
	0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42, 0x43, 0x83, 0x41, 0x81, 0x80, 0x40
};

uint16_t getCrc16(uint8_t *pucData, uint16_t uLen)
{
	uint8_t ucCRCHi = 0xFF;
	uint8_t ucCRCLo = 0xFF;
	uint16_t usIndex = 0;

	while (uLen--)
	{
		usIndex = ucCRCLo ^ *pucData++;
		ucCRCLo = ucCRCHi ^ aucCRCHi[usIndex];
		ucCRCHi = aucCRCLo[usIndex];
	}

	return (ucCRCHi << 8 | ucCRCLo);
}

/**
 * @brief 取得十进制字符的ASCII码数组
 * @param[in] ucVal:对象数值
 * @param[in] ASCII码数组起始地址
 * @return 取得ASCII码值字节数
 * @note
 * @attention
 */
uint8_t uchartoasc(uint32_t ulVal, uint8_t *pucDst)
{
    uint8_t aucASC[10] = {0};
    uint8_t ucRet = 1;
    
    for(ucRet=1; ucRet<=10; ucRet++)
    {
        aucASC[10-ucRet] = (ulVal % 10) + '0';
        ulVal /= 10;
        if(0 == ulVal)
            break;
    }
    memcpy((void*)pucDst, (void*)(&aucASC[10-ucRet]), (uint32_t)ucRet);
    return ucRet;
}
 
/**
 * @brief 取得十进制数的ASCII码值
 * @param[in] uVal:对象数值
 * @param[in] ucDecBit:位置
 * @return 取得ASCII码值
 * @note
 * @attention
 *    数值长度：16位（0xFFFF）
 */
uint8_t GetDecBitToHexFmt(uint16_t uVal, uint8_t ucDecBit)
{
	uint16_t uCalculate 	= uVal;
	uint8_t  ucRet				= 0;

	/* 万	*/
	if (DEC_BIT_WAN == ucDecBit && uCalculate / 10000 > 0)
	{
		ucRet = uCalculate / 10000 + 0x30;
	}
	
	/* 千	*/		
	uCalculate = uCalculate % 10000;
	if (DEC_BIT_QIAN == ucDecBit && (uCalculate / 1000) > 0)
	{
		ucRet = uCalculate / 1000 + 0x30;
	}
		
	/* 百	*/
	uCalculate = uCalculate % 1000;
	if (DEC_BIT_BAI == ucDecBit && (uCalculate / 100) > 0)
	{
		ucRet = uCalculate / 100 + 0x30;
	}
		
	/* 十	*/
	uCalculate = uCalculate % 100;
	if (DEC_BIT_SHI == ucDecBit && (uCalculate / 10) > 0)
	{
		ucRet = uCalculate / 10 + 0x30;
	}
	
	/* 个位	*/
	if (DEC_BIT_GE == ucDecBit)
	{
		uCalculate 	= uCalculate % 10;
		ucRet 		  = uCalculate + 0x30;
	}
	
	return ucRet;
}

/**
 * @brief 一个数据值(半个字节：如 0xE->'E')
 * @param[in] ucHexHalfByte:转换对象数据(半字节数据)
 * @return 半字节数据的Ascii码表示
 * @note
 * @attention
 */
uint8_t CvtHex2AsciiHalfByte(uint8_t ucHexHalfByte)
{
    uint8_t ucRetAscii = 0;

    /*
     * 大写A~F之间
     */
    if (ucHexHalfByte >= 0x0A && ucHexHalfByte <= 0x0F)
    {
        ucRetAscii =ucHexHalfByte + 0x37;
    }
    /*
     * 数字
     */
    else if (ucHexHalfByte <= 0x09)
    {
        ucRetAscii =ucHexHalfByte + 0x30;
    }

    return ucRetAscii;
}

/**
 * @brief 十六进制数据 =》 Ascii码表示数据（2字节） exp) 0x2D => "2D"
 * @param[out] pucAsciiData:转换后的Ascii码数据
 * @param[in] ucData:一个字节Ascii数据首地址(两个字符)
 * @return 无
 * @note
 * @attention
 *   1字节数据，低4位，在右，高4位在左，所以要对调。 如:0(高4位） 2（低4位）
 */
void CvtHex2Ascii(uint8_t* pucAsciiData, uint8_t ucData)
{
    if (NULL == pucAsciiData)
    {
        return;
    }
    else
    {
        /*
         * 拼接成两个字节Ascii数据
         */
        pucAsciiData[1] = CvtHex2AsciiHalfByte(0x0F & ucData);  //低4位
        pucAsciiData[0] = CvtHex2AsciiHalfByte(ucData >> 4);    //高4位
    }
}

/**
 * @brief 一个数据值(半个字节：如 0E中 'E'->0xE)
 * @param[in] ucAscii:转换对象数据(Ascii码)
 * @return 十六进制值
 * @note
 * @attention
*    存在F以上表示的情况，所以作了必要修改
 */
uint8_t CvtAscii2HexHalfByte(uint8_t ucAscii)
{
    uint8_t ucHexVal = 0;
    
    /*
     * 大字A~Z之间
     */
    if (ucAscii >= 'A' && ucAscii <= 'F')
    {
        ucHexVal = ucAscii + 10 - 0x41;
    }
    /*
     * 小写a~z之间
     */
    else if (ucAscii >= 'a' && ucAscii <= 'f')
    {
        ucHexVal = ucAscii + 10 - 0x61;
    }
    /*
     * 数字
     */
    else if (ucAscii >= '0' && ucAscii <= '9')
    {
        ucHexVal = ucAscii - 0x30;
    }
     /*
     * 出错
     */
    else
    {
        ucHexVal = 0xFF;
    }
		
    return ucHexVal;
}

/**
 * @brief Ascii码表示数据 =》 十六进制数据（2字节） exp) "2D" => 0x2D
 * @param[in] ucData:一个字节Ascii数据首地址(两个字符)
 * @return 十六进制值
 * @note
 * @attention
 */
uint8_t CvtAscii2Hex(const uint8_t* pucData)
{
	uint8_t ucRet = 0;
	uint8_t ucTmpHexData0 = 0;
	uint8_t ucTmpHexData1 = 0;

	if (NULL == pucData)
	{
		ucRet = 0;
	}
	else
	{
		ucTmpHexData1 = CvtAscii2HexHalfByte(pucData[0]);
		ucTmpHexData0 = CvtAscii2HexHalfByte(pucData[1]);
		ucRet = (ucTmpHexData1 << 4) | ucTmpHexData0;
	}

	return ucRet;
}
//获取第n个给定字符的位置
char* strnchr(char *s1, char c, uint16_t n)
{
    char *last;
    char *current;
    last = NULL;
    if ( c != '\0' )
    {
        current = strchr((char *)s1, c);
        while ((current != NULL) && (n > 0))
        {
            last = current; 
            n--; 
            current = strchr((char *)(last + 1), c);

        }
    }
    if ( n > 0 )
        last = NULL;
    return last;
}

//从pucStr中寻找puctag的串，找最长uLen个字符，有返回第i+1位，无返回0
uint16_t foundString(const uint8_t *pucStr, const char *puctag, uint16_t uLen)
{
	uint16_t i = 0, j = 0;
	while (i < uLen)
	{
		j = 0;
		while (pucStr[i+j] == puctag[j])
		{
			j++;
			if (puctag[j] == 0)
			{return i+1;}
		}
		i++;
		if ((i >= uLen) || (pucStr[i] == 0))
		{break;}
	}
	
	return 0;
}

/*****************************************************************************
 * 函 数 名  : MyStrstr
 * 负 责 人  : maxy
 * 创建日期  : 2022年10月13日
 * 函数功能  : 在str中查找substr字符串是否存在
 * 输入参数  : 字符串
 * 输出参数  : 无
 * 返 回 值  : 查找到字符串起始位置，-1表示未查找到
 * 调用关系  :
 * 其    它  :
*****************************************************************************/
int MyStrstr(char *str, char *substr)
{
    int num = 0;
	while (*str != '\0')
	{
		if (*str != *substr)
		{
			str++;
			num++;
			continue;
		}

		//创建临时指针
		char* tmpstr = str;
		char* tmpsubstr = substr;

		while (*tmpsubstr != '\0')
		{
			if (*tmpstr != *tmpsubstr)
			{
				//匹配失败
				str++;
				num++;
				break;
			}
			tmpstr++;
			tmpsubstr++;
		}
		if (*tmpsubstr == '\0')//匹配成功
		{
			return num;
		}
	}
	return -1;
}