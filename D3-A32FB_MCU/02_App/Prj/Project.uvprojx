# Keil uVision project Project.uvprojx, settings and files
target D3_A32FB_GD32E503RE (6160000::V6.16::ARMCLANG)
  device: GD32E503RE GigaDevice
  pack: GigaDevice.GD32E50x_DFP.1.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: D3_A32FB_GD32E503 +hex
  AfterMake: fromelf.exe --bin -o ./gd32e503/bin/D3_A32FB_GD32E503.bin ./gd32e503/build/D3_A32FB_GD32E503.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: GD32E50X,GD32E50X_HD
  c misc: -Wno-invalid-source-encoding
  c include: ..\Src\Core\Inc;..\Src\Drivers\GD32E50x_Firmware_Library\GD32E50x_standard_peripheral\Include;..\Src\Drivers\GD32E50x_Firmware_Library\CMSIS\GD\GD32E50x\Include;..\Src\Core;..\Src\BSW\SystemService\OS\FreeRTOS\Source\include;..\Src\BSW\SystemService\OS\FreeRTOS\Source\CMSIS_RTOS_V2;..\Src\BSW\SystemService\OS\FreeRTOS\Source\portable\GCC\ARM_CM33_NTZ\non_secure;..\Src\Drivers\GD32E50x_Firmware_Library\CMSIS;..\Src;..\Src\BSW\MCAL;..\Src\Common;..\Src\BSW\SystemService\SystemM;..\Src\BSW\SystemService\TM;..\Src\BSW\DebugService\LogM;..\Src\BSW\DebugService\Console;..\Src\ThirdPartyLib\FlashDB\port\fal\inc;..\Src\ThirdPartyLib\FlashDB\inc;..\Src\BSW\MemoryService\FlashDB_Adapter;..\Src\BSW\MemoryService\MemIf;..\Src\BSW\MemoryService\NVM;..\Src\BSW\MemoryService\EA;..\Src\ThirdPartyLib\LetterShell;..\Src\BSW\ComplexDeviceDriver\CP;..\Src\BSW\ComplexDeviceDriver\Meter;..\Src\BSW\ComplexDeviceDriver\PE;..\Src\BSW\ComplexDeviceDriver\RCD;..\Src\BSW\ComplexDeviceDriver\Relay;..\Src\BSW\ComplexDeviceDriver\Sensor;..\Src\BSW\ComplexDeviceDriver\Led;..\Src\BSW\ComplexDeviceDriver\Net;..\Src\BSW\ComplexDeviceDriver\ModeM;..\Src\BSW\ComplexDeviceDriver\Card;..\Src\ASW\ASW_COM;..\Src\ASW\ASW_CHG\Charge;..\Src\ASW\ASW_CHG\Errorhandle;..\Src\ASW\ASW_CHG\EVSE;..\Src\ASW\ASW_CHG\LedEvent;..\Src\ASW\ASW_CHG\Temp;..\Src\ASW\ASW_CHG\VoltCur;..\Src\ASW\ASW_COM\Asw_PlatM;..\Src\ASW\ASW_COM\Asw_IotProtocol\Protocol_GN;..\Src\ASW\ASW_COM\Asw_IotProtocol\Protocol_OM;..\Src\ASW\ASW_COM\Asw_IotProtocol\Protocol_XDT;..\Src\ASW\ASW_COM\Asw_IotProtocol\Protocol_YKC21;..\Src\ASW\ASW_COM\Asw_IotProtocol\Protocol_YKC16;..\Src\ASW\ASW_COM\Asw_IotProtocol\Protocol_GWE;..\Src\ASW\ASW_COM\Asw_IotProtocol\Protocol_XJ;..\Src\ASW\ASW_COM\Asw_IotProtocol\Protocol_AP;..\Src\ASW\ASW_COM\Asw_Monitor;..\Src\ASW\ASW_COM\Asw_ChargeIf;..\Src\BSW\SystemService\UCM;..\Src\BSW\SystemService\Snapshot;..\Src\ThirdPartyLib\Mbedtls\mbedtls\include;..\Src\ThirdPartyLib\CmBacktrace;..\Src\BSW\SystemService\WdgM;..\Src\ThirdPartyLib\cJSON;..\Src\ASW\ASW_COM\Asw_IotProtocol\Protocol_AHTT
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x7c000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --keep shellCommand*
  group ASW/CHG
    ../Src/ASW/ASW_CHG/Charge/: Asw_Charge.c Asw_ChargeConfig.c
    ../Src/ASW/ASW_CHG/Errorhandle/: Asw_ErrorHandle.c Asw_ErrorHandleConfig.c
    ../Src/ASW/ASW_CHG/EVSE/: Asw_EVSE.c
    ../Src/ASW/ASW_CHG/LedEvent/: Asw_LedEvent.c Asw_LedEventConfig.c
    ../Src/ASW/ASW_CHG/Temp/: Asw_TempHandle.c
    ../Src/ASW/ASW_CHG/VoltCur/: Asw_VoltCurHandle.c
  group ASW/COM
    ../Src/ASW/ASW_COM/Asw_PlatM/: Asw_PlatM.c Asw_PlatMConfig.c
    ../Src/ASW/ASW_COM/Asw_IotProtocol/Protocol_GN/: Asw_IotProtoGNM.c Asw_IotProtoGNRecv.c Asw_IotProtoGNSend.c
    ../Src/ASW/ASW_COM/Asw_IotProtocol/Protocol_OM/: Asw_IotProtoOMM.c Asw_IotProtoOMRecv.c Asw_IotProtoOMSend.c
    ../Src/ASW/ASW_COM/Asw_IotProtocol/Protocol_XDT/: Asw_IotProtoXDTM.c Asw_IotProtoXDTRecv.c Asw_IotProtoXDTSend.c
    ../Src/ASW/ASW_COM/Asw_IotProtocol/Protocol_YKC21/: Asw_IotProtoYKC21M.c Asw_IotProtoYKC21Recv.c Asw_IotProtoYKC21Send.c Asw_lotProtoYKC21aes.c Asw_lotProtoYKC21rsaOwn.c
    ../Src/ASW/ASW_COM/Asw_IotProtocol/Protocol_GWE/: Asw_IotProtoGWEM.c Asw_IotProtoGWERecv.c Asw_IotProtoGWESend.c
    ../Src/ASW/ASW_COM/Asw_Monitor/: Asw_Monitor.c Asw_MonitorConfig.c
    ../Src/ASW/ASW_COM/Asw_ChargeIf/: Asw_ChargeIf.c
    ../Src/ASW/ASW_COM/Asw_IotProtocol/Protocol_YKC16/: Asw_IotProtoYKC16M.c Asw_IotProtoYKC16Recv.c Asw_IotProtoYKC16Send.c
    ../Src/ASW/ASW_COM/Asw_IotProtocol/Protocol_XJ/: Asw_IotProtoXJM.c Asw_IotProtoXJRecv.c Asw_IotProtoXJSend.c
    ../Src/ASW/ASW_COM/Asw_IotProtocol/Protocol_AP/: Asw_IotProtoAPM.c Asw_IotProtoAPRecv.c Asw_IotProtoAPSend.c
    ../Src/ASW/ASW_COM/Asw_IotProtocol/Protocol_AHTT/: Asw_IotProtoAHTTM.c Asw_IotProtoAHTTRecv.c Asw_IotProtoAHTTSend.c
  group BSW/ComplexDeviceDriver
    ../Src/BSW/ComplexDeviceDriver/CP/: Cdd_CP.c Cdd_CPConfig.c
    ../Src/BSW/ComplexDeviceDriver/RCD/: Cdd_Rcd.c
    ../Src/BSW/ComplexDeviceDriver/PE/: Cdd_PE.c
    ../Src/BSW/ComplexDeviceDriver/Meter/: Cdd_MeterM.c Cdd_MeterMConfig.c Cdd_Drv_BL0942.c Cdd_Drv_BL0942Config.c
    ../Src/BSW/ComplexDeviceDriver/Relay/: Cdd_Relay.c Cdd_RelayConfig.c
    ../Src/BSW/ComplexDeviceDriver/Sensor/: Cdd_Sensor.c Cdd_SensorConfig.c
    ../Src/BSW/ComplexDeviceDriver/Led/: Cdd_Drv_WS2812B.c Cdd_Drv_WS2812BConfig.c Cdd_LedM.c Cdd_LedMConfig.c
    ../Src/BSW/ComplexDeviceDriver/Net/: Cdd_NetM.c Cdd_NetMConfig.c Cdd_Drv_EG800AK.c Cdd_Drv_EG800AKConfig.c AT_MQTT.c AT_Module.c AT_FTP.c AT_TCP.c AT_HTTP.c
    ../Src/BSW/ComplexDeviceDriver/ModeM/: Cdd_ModeM.c
    ../Src/BSW/ComplexDeviceDriver/Card/: Cdd_CardM.c Cdd_CardMConfig.c Cdd_Drv_LS5120.c Cdd_Drv_LS5120Config.c
  group BSW/MemoryService
    ../Src/BSW/MemoryService/FlashDB_Adapter/: fal_flash_w25qxx_port.c FlashDB_KVDB_Adapt.c FlashDB_TSDB_Adapt.c FlashDB_KVDB_AdaptConfig.c FlashDB_TSDB_AdaptConfig.c
    ../Src/BSW/MemoryService/EA/: W25QXX.c
    ../Src/BSW/MemoryService/NVM/: MS_Nvm.c MS_NvmConfig.c
    ../Src/BSW/MemoryService/MemIf/: MS_MemIf.c MS_MemIfConfig.c
  group BSW/MCAL
    ../Src/BSW/MCAL/: Mcal_Mcu.c Mcal_If.c Mcal_Port.c Mcal_PortConfig.c Mcal_PWM.c Mcal_PWMConfig.c Mcal_ADC.c Mcal_ADCConfig.c Mcal_Uart.c Mcal_UartConfig.c Mcal_IWDG.c Mcal_SPI.c Mcal_SPIConfig.c
  group BSW/DebugService
    ../Src/BSW/DebugService/LogM/: DS_LogM.c DS_LogMConfig.c
    ../Src/BSW/DebugService/Console/: DS_Console.c DS_ConsoleConfig.c
  group BSW/SystemService
    ../Src/BSW/SystemService/SystemM/: SS_SystemM.c
    ../Src/BSW/SystemService/TM/: SS_Tm.c
    ../Src/BSW/SystemService/UCM/: SS_Ucm.c
    ../Src/BSW/SystemService/Snapshot/: SS_Snapshot.c SS_SnapshotConfig.c
    ../Src/BSW/SystemService/WdgM/: SS_WdgM.c SS_WdgMConfig.c
  group ThridParty/Mbedtls
    ../Src/ThirdPartyLib/Mbedtls/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers.c psa_crypto_ecp.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_crypto_storage.c psa_its_file.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_keys.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group ThirdParty/FlashDB
    ../Src/ThirdPartyLib/FlashDB/src/: fdb.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
  group ThirdParty/Fal
    ../Src/ThirdPartyLib/FlashDB/port/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group ThirdParty/LetterShell
    ../Src/ThirdPartyLib/LetterShell/: shell.c shell_cmd_list.c shell_ext.c shell_port.c
  group ThirdParty/cJSON
    ../Src/ThirdPartyLib/cJSON/: cJSON.c
  group ThirdParty/CmBacktrace
    ../Src/ThirdPartyLib/CmBacktrace/: cm_backtrace.c cmb_fault.S
  group Drivers/GD32E50x_Driver
    ../Src/Drivers/GD32E50x_Firmware_Library/GD32E50x_standard_peripheral/Source/: gd32e50x_adc.c gd32e50x_bkp.c gd32e50x_can.c gd32e50x_cmp.c gd32e50x_crc.c gd32e50x_ctc.c gd32e50x_dac.c gd32e50x_dbg.c gd32e50x_dma.c gd32e50x_enet.c gd32e50x_exmc.c gd32e50x_exti.c gd32e50x_fmc.c gd32e50x_fwdgt.c gd32e50x_gpio.c gd32e50x_i2c.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_rtc.c gd32e50x_sdio.c gd32e50x_shrtimer.c gd32e50x_spi.c gd32e50x_sqpi.c gd32e50x_timer.c gd32e50x_tmu.c gd32e50x_usart.c gd32e50x_wwdgt.c
  group Common
    ../Src/Common/: Common.c Filter.c CycleBuf.c FrameQueue.c md5.c myMalloc.c
  group Core
    ../Src/Drivers/GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/: system_gd32e50x.c
    ../Src/Drivers/GD32E50x_Firmware_Library/CMSIS/GD/GD32E50x/Source/ARM/: startup_gd32e50x_hd.s
    ../Src/: SysCfg.h Version.h
    ../Src/Core/: main.c portTask.c utils.c
  group OS
    ../Src/BSW/SystemService/OS/FreeRTOS/Source/portable/GCC/ARM_CM33_NTZ/non_secure/: portasm.c port.c
    ../Src/BSW/SystemService/OS/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Src/BSW/SystemService/OS/FreeRTOS/Source/portable/Common/: mpu_wrappers.c
    ../Src/BSW/SystemService/OS/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Src/BSW/SystemService/OS/FreeRTOS/Source/: timers.c tasks.c stream_buffer.c queue.c list.c event_groups.c croutine.c
    ../Src/Core/: freertos.c
software components: CMSIS:CORE 5.5.0
